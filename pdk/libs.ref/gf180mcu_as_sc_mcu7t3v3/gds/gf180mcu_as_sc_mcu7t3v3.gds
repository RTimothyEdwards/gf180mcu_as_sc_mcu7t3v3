* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__oai21_4 A B C VDD VNW VSS Y
XM1 VSS A n1 VSUBS nfet_03v3 w=1u l=0.28u m=4
XM2 n1 B VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM3 Y C n1 VSUBS nfet_03v3 w=1u l=0.28u m=4
XM4 n2 A VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
XM5 Y B n2 VNW pfet_03v3 w=1.38u l=0.28u m=4
XM6 Y C VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__oai21_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,10.64,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,11.07,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,10.5,1.34), (0.14,2.2,10.5,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 0.58, 0.12, 0.28, 1.49, 7, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 6.98, 0.12, 0.28, 1.475, 4, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 6.98, 1.96, 0.28, 1.84, 4, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 0.58, 1.975, 0.28, 1.825, 7, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(6.18,0.12,6.46,1.6), (6.98,1.595,9.66,1.96), (5.965,1.6,6.46,1.965), (0.44,1.61,2.46,1.975), (2.98,1.61,5.66,1.975), (6.18,1.965,6.46,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,10.72,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,10.72,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 1.01, 0.41, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 1.81, 0.925, 0.22, 0.22, 3, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 7.25, 1.67, 0.22, 0.22, 5, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 0.6, 1.685, 0.22, 0.22, 4, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 3.25, 1.685, 0.22, 0.22, 5, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 6.61, 3.29, 0.22, 0.22, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(8.21,0.535,8.43,0.755), (9.81,0.535,10.03,0.755), (6.61,0.795,6.83,1.015), (0.21,0.8,0.43,1.02), (7.41,0.995,7.63,1.215), (9.01,0.995,9.23,1.215), (6.035,1.67,6.255,1.89), (1.01,2.625,1.23,2.845), (3.41,2.625,3.63,2.845), (9.01,2.625,9.23,2.845), (5.01,2.63,5.23,2.85), (7.41,2.63,7.63,2.85), (2.61,2.735,2.83,2.955), (4.21,3.105,4.43,3.325), (5.81,3.105,6.03,3.325), (0.21,3.29,0.43,3.51), (1.81,3.29,2.03,3.51)])
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 1.005, 0.3, 0.23, 0.39, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 6.605, 3.23, 0.23, 0.39, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,10.64,0.3), (6.605,0.53,10.09,0.76), (0.205,0.74,0.435,0.92), (6.605,0.76,6.835,0.92), (0.205,0.92,6.835,1.15), (7.26,0.99,10.245,1.22), (9.85,1.22,10.245,2.62), (6.03,1.6,6.26,2.16), (0.48,1.66,2.355,1.93), (2.985,1.66,5.615,1.93), (6.99,1.66,9.62,1.93), (1.915,1.93,2.355,2.16), (1.915,2.16,6.26,2.39), (0.855,2.62,2.835,2.85), (3.235,2.62,10.245,2.855), (2.605,2.85,2.835,3.1), (9.85,2.855,10.245,2.86), (2.605,3.1,6.09,3.33), (0.205,3.23,0.435,3.62), (1.805,3.23,2.035,3.62), (0,3.62,10.64,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,10.64,0.3), (9.85,0.99,10.245,2.86), (2.985,1.66,5.615,1.93), (6.99,1.66,9.62,1.93), (0.48,1.675,2.355,1.93), (0,3.62,10.64,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,11.07,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (5.32,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (5.32,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (1.417,1.802), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (4.3,1.795), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (8.305,1.795), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (10.047,1.925), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__oai21_4.gds')
