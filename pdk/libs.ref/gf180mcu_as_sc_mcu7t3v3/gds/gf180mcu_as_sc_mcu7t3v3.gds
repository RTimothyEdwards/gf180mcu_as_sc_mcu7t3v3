* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__oai22_4 A B C D VDD VNW VSS Y
XM1 VSS D n1 VSUBS nfet_03v3 w=1u l=0.28u m=4
XM2 n1 C VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM3 Y A n1 VSUBS nfet_03v3 w=1u l=0.28u m=4
XM4 n1 B Y VSUBS nfet_03v3 w=1u l=0.28u m=4
XM5 n2 D VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
XM6 Y C n2 VNW pfet_03v3 w=1.38u l=0.28u m=4
XM7 n3 A VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
XM8 Y B n3 VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__oai22_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,13.44,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,13.87,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,13.3,1.34), (0.14,2.2,13.3,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 0.58, 0.12, 0.28, 1.47, 7, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 6.98, 0.12, 0.28, 1.47, 8, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 0.58, 1.95, 0.28, 1.85, 7, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 6.98, 1.95, 0.28, 1.85, 8, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(6.18,0.12,6.46,1.595), (0.58,1.59,2.46,1.95), (2.98,1.59,5.66,1.95), (6.98,1.59,8.86,1.95), (9.38,1.59,12.06,1.95), (12.3,1.59,12.86,1.95), (5.935,1.595,6.46,1.955), (6.18,1.955,6.46,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,13.52,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,13.52,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 1.01, 0.41, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 8.21, 0.535, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 0.21, 0.925, 0.22, 0.22, 5, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 7.41, 0.995, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 3.12, 1.66, 0.22, 0.22, 5, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 9.67, 1.66, 0.22, 0.22, 5, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 2.61, 3.165, 0.22, 0.22, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.175,1.66,1.395,1.88), (1.645,1.66,1.865,1.88), (7.755,1.66,7.975,1.88), (8.225,1.66,8.445,1.88), (12.37,1.66,12.59,1.88), (6.035,1.665,6.255,1.885), (3.41,2.66,3.63,2.88), (5.01,2.66,5.23,2.88), (9.81,2.705,10.03,2.925), (11.41,2.705,11.63,2.925), (1.01,2.775,1.23,2.995), (7.41,2.775,7.63,2.995), (9.01,3.01,9.23,3.23), (10.61,3.165,10.83,3.385), (12.21,3.165,12.43,3.385), (0.21,3.29,0.43,3.51), (1.81,3.29,2.03,3.51), (6.61,3.29,6.83,3.51), (8.21,3.29,8.43,3.51), (13.01,3.29,13.23,3.51)])
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 1.005, 0.3, 0.23, 0.39, 4, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,13.44,0.3), (6.66,0.53,13.29,0.76), (6.66,0.76,6.89,0.92), (0.205,0.865,0.435,0.92), (0.205,0.92,6.89,1.15), (7.12,0.99,13.28,1.22), (0.205,1.15,0.435,1.205), (2.32,1.15,5.065,1.155), (7.12,1.22,7.35,1.38), (12.825,1.22,13.28,2.7), (6.49,1.38,7.35,1.61), (0.86,1.59,2.18,1.95), (2.98,1.59,5.38,1.95), (7.58,1.59,8.625,1.95), (9.38,1.59,12.06,1.95), (12.365,1.59,12.595,2.18), (6.03,1.595,6.26,2.18), (6.49,1.61,6.72,2.655), (1.95,1.95,2.18,2.18), (8.395,1.95,8.625,2.18), (1.95,2.18,6.26,2.41), (8.395,2.18,12.595,2.41), (3.35,2.655,6.72,2.885), (9.75,2.7,13.28,2.93), (0.925,2.77,2.835,3), (7.35,2.77,9.235,3), (2.55,3,2.835,3.16), (9.005,3,9.235,3.16), (2.55,3.16,6.09,3.39), (9.005,3.16,12.49,3.39), (0.205,3.23,0.435,3.62), (1.805,3.23,2.035,3.62), (6.605,3.23,6.835,3.62), (8.205,3.23,8.435,3.62), (13.005,3.23,13.235,3.62), (0,3.62,13.44,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,13.44,0.3), (12.825,0.99,13.28,2.93), (0.86,1.59,2.18,1.95), (2.98,1.59,5.38,1.95), (7.58,1.59,8.625,1.95), (9.38,1.59,12.06,1.95), (0,3.62,13.44,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,13.87,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (6.72,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (6.72,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (8.102,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (10.72,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (4.18,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (1.52,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (13.052,1.96), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__oai22_4.gds')
