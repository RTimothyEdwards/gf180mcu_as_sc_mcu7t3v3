* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__oa211_4 A B C D VDD VNW VSS Y
XM1 VSS A n1 VSUBS nfet_03v3 w=1u l=0.28u
XM2 n1 B VSS VSUBS nfet_03v3 w=1u l=0.28u
XM3 n2 C n1 VSUBS nfet_03v3 w=1u l=0.28u
XM4 n3 D n2 VSUBS nfet_03v3 w=1u l=0.28u
XM5 Y n3 VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM6 n4 A VDD VNW pfet_03v3 w=1.38u l=0.28u
XM7 n3 B n4 VNW pfet_03v3 w=1.38u l=0.28u
XM8 VDD C n3 VNW pfet_03v3 w=1.38u l=0.28u
XM9 n3 D VDD VNW pfet_03v3 w=1.38u l=0.28u
XM10 Y n3 VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__oa211_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,7.84,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,8.27,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,3.7,1.34), (3.98,0.34,7.54,1.34), (0.14,2.2,3.7,3.58), (3.98,2.2,7.54,3.58)])
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.535), (1.38,0.12,1.66,1.535), (2.18,0.12,2.46,1.56), (2.98,0.12,3.26,1.54), (4.42,0.12,4.7,1.59), (5.22,0.12,5.5,1.59), (6.02,0.12,6.3,1.595), (6.82,0.12,7.1,1.63), (0.265,1.535,0.86,2.005), (1.1,1.535,1.66,2.005), (2.98,1.54,3.435,2.02), (2.06,1.56,2.51,2.05), (3.75,1.59,5.5,1.595), (3.75,1.595,6.3,1.63), (3.75,1.63,7.1,1.91), (3.75,1.91,5.5,1.95), (6.02,1.91,7.1,1.98), (4.42,1.95,4.7,3.8), (5.22,1.95,5.5,3.8), (6.02,1.98,6.3,3.8), (6.82,1.98,7.1,3.8), (0.58,2.005,0.86,3.8), (1.38,2.005,1.66,3.8), (2.98,2.02,3.26,3.8), (2.18,2.05,2.46,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,7.92,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,7.92,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 7.25, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.01,0.41,1.23,0.63), (4.05,0.41,4.27,0.63), (5.65,0.41,5.87,0.63), (7.25,0.495,7.47,0.715), (0.21,0.7,0.43,0.92), (3.41,0.885,3.63,1.105), (1.81,0.925,2.03,1.145), (7.25,0.965,7.47,1.185), (4.85,1.05,5.07,1.27), (6.45,1.05,6.67,1.27), (3.82,1.66,4.04,1.88), (0.43,1.665,0.65,1.885), (1.17,1.665,1.39,1.885), (3.095,1.675,3.315,1.895), (2.185,1.685,2.405,1.905), (4.85,2.455,5.07,2.675), (6.45,2.455,6.67,2.675), (1.81,2.775,2.03,2.995), (3.41,2.775,3.63,2.995), (4.85,2.925,5.07,3.145), (6.45,2.925,6.67,3.145), (0.21,3.29,0.43,3.51), (2.61,3.29,2.83,3.51), (4.05,3.29,4.27,3.51), (5.65,3.29,5.87,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,7.84,0.3), (1.005,0.3,1.235,0.69), (4.045,0.3,4.275,0.69), (5.645,0.3,5.875,0.69), (7.245,0.3,7.475,1.425), (0.205,0.64,0.435,0.92), (3.31,0.88,3.895,1.11), (0.205,0.92,2.09,1.15), (4.845,0.99,5.255,1.545), (6.445,0.99,6.855,1.545), (3.665,1.11,3.895,1.645), (2.98,1.34,3.435,2.5), (2.06,1.38,2.51,2.46), (0.265,1.535,0.815,2.005), (1.1,1.535,1.395,2.605), (4.845,1.545,6.855,1.875), (3.665,1.645,4.1,1.895), (4.845,1.875,5.255,3.39), (6.445,1.875,6.855,3.39), (3.665,1.895,3.895,2.77), (0.265,2.005,0.595,2.645), (7.245,2.155,7.475,3.62), (1.75,2.77,3.895,3), (0.205,3.23,0.435,3.62), (2.605,3.23,2.835,3.62), (4.045,3.23,4.275,3.62), (5.645,3.23,5.875,3.62), (0,3.62,7.84,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,7.84,0.3), (4.845,0.99,5.255,3.39), (6.445,0.99,6.855,3.39), (2.98,1.34,3.435,2.5), (2.06,1.38,2.51,2.46), (0.265,1.535,0.595,2.645), (1.1,1.535,1.395,2.605), (0,3.62,7.84,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,8.27,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (3.92,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (3.92,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (0.43,2.09), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (1.247,2.07), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (2.285,1.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (3.207,1.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (6.65,2.19), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (5.05,2.19), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__oa211_4.gds')
