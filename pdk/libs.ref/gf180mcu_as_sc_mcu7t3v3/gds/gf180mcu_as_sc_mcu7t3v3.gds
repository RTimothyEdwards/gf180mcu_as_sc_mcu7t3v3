* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__oai22_2 A B C D VDD VNW VSS Y
XM1 Y A n1 VSUBS nfet_03v3 w=1u l=0.28u m=2
XM2 Y B n1 VSUBS nfet_03v3 w=1u l=0.28u m=2
XM3 VSS C n1 VSUBS nfet_03v3 w=1u l=0.28u m=2
XM4 VSS D n1 VSUBS nfet_03v3 w=1u l=0.28u m=2
XM5 VDD A n2 VNW pfet_03v3 w=1.38u l=0.28u m=2
XM6 Y B n2 VNW pfet_03v3 w=1.38u l=0.28u m=2
XM7 Y C n3 VNW pfet_03v3 w=1.38u l=0.28u m=2
XM8 VDD D n3 VNW pfet_03v3 w=1.38u l=0.28u m=2
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__oai22_2')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,7.84,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,8.27,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,7.54,1.34), (0.14,2.2,3.7,3.58), (3.98,2.2,7.54,3.58)])
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.59), (1.38,0.12,1.66,1.59), (2.18,0.12,2.46,1.6), (2.98,0.12,3.26,1.6), (4.42,0.12,4.7,1.59), (5.22,0.12,5.5,1.59), (6.02,0.12,6.3,1.585), (6.82,0.12,7.1,1.585), (6.02,1.585,7.1,1.945), (0.58,1.59,1.66,1.95), (4.42,1.59,5.5,1.95), (2.18,1.6,3.26,1.96), (6.02,1.945,6.3,3.8), (6.82,1.945,7.1,3.8), (0.58,1.95,0.86,3.8), (1.38,1.95,1.66,3.8), (4.42,1.95,4.7,3.8), (5.22,1.95,5.5,3.8), (2.18,1.96,2.46,3.8), (2.98,1.96,3.26,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,7.92,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,7.92,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(4.85,0.41,5.07,0.63), (6.45,0.41,6.67,0.63), (1.81,0.535,2.03,0.755), (3.41,0.535,3.63,0.755), (0.21,0.67,0.43,0.89), (5.65,0.925,5.87,1.145), (7.25,0.925,7.47,1.145), (1.01,0.995,1.23,1.215), (2.61,0.995,2.83,1.215), (6.325,1.655,6.545,1.875), (0.97,1.66,1.19,1.88), (4.69,1.66,4.91,1.88), (2.535,1.67,2.755,1.89), (2.61,2.29,2.83,2.51), (4.85,2.29,5.07,2.51), (7.25,2.46,7.47,2.68), (1.81,2.475,2.03,2.695), (0.21,2.73,0.43,2.95), (4.05,2.915,4.27,3.135), (3.41,2.92,3.63,3.14), (5.65,3.165,5.87,3.385), (1.01,3.29,1.23,3.51), (6.45,3.29,6.67,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,7.84,0.3), (4.845,0.3,5.075,0.69), (6.445,0.3,6.675,0.69), (0.205,0.53,4.36,0.76), (0.205,0.76,0.435,1.18), (4.13,0.76,4.36,0.92), (7.245,0.865,7.475,0.92), (4.13,0.92,7.475,1.15), (0.8,0.99,3.7,1.22), (7.245,1.15,7.475,1.205), (3.21,1.22,3.7,2.285), (6.02,1.585,6.82,1.945), (4.42,1.59,5.22,1.95), (2.18,1.6,2.98,1.96), (0.515,1.62,1.285,1.92), (2.31,2.285,5.13,2.515), (7.245,2.4,7.475,2.455), (1.805,2.415,2.035,2.47), (5.645,2.455,7.475,2.685), (0.205,2.47,2.035,2.7), (5.645,2.685,5.875,3.16), (7.245,2.685,7.475,2.74), (0.205,2.7,0.435,3.16), (1.805,2.7,2.035,2.915), (4.045,2.855,4.275,3.16), (1.805,2.915,3.69,3.145), (4.045,3.16,5.93,3.39), (1.005,3.23,1.235,3.62), (6.445,3.23,6.675,3.62), (0,3.62,7.84,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,7.84,0.3), (3.21,0.99,3.7,2.515), (6.02,1.585,6.82,1.945), (4.42,1.59,5.22,1.95), (2.18,1.6,2.98,1.96), (0.515,1.62,1.285,1.92), (0,3.62,7.84,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,8.27,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (3.92,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (3.92,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (0.9,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (2.58,1.78), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (4.82,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (6.42,1.765), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (3.455,1.752), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__oai22_2.gds')
