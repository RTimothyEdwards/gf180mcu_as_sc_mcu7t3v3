* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__oai21_2 A B C VDD VNW VSS Y
XM1 VSS A n1 VSUBS nfet_03v3 w=1u l=0.28u m=2
XM2 n1 B VSS VSUBS nfet_03v3 w=1u l=0.28u m=2
XM3 Y C n1 VSUBS nfet_03v3 w=1u l=0.28u m=2
XM4 n2 A VDD VNW pfet_03v3 w=1.38u l=0.28u m=2
XM5 Y B n2 VNW pfet_03v3 w=1.38u l=0.28u m=2
XM6 Y C VDD VNW pfet_03v3 w=1.38u l=0.28u m=2
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__oai21_2')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,5.6,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,6.03,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,5.46,1.34), (0.14,2.2,5.46,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 1.38, 0.12, 0.28, 1.49, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 1.38, 1.97, 0.28, 1.83, 3, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.595), (3.78,0.12,4.06,1.615), (4.58,0.12,4.86,1.595), (0.37,1.595,0.86,1.955), (4.58,1.595,5.075,1.615), (1.38,1.61,2.46,1.97), (2.765,1.61,3.26,1.97), (3.78,1.615,5.075,1.945), (3.78,1.945,4.06,3.8), (4.58,1.945,5.075,1.955), (0.58,1.955,0.86,3.8), (4.58,1.955,4.86,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,5.68,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,5.68,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.01,0.41,1.23,0.63), (2.61,0.41,2.83,0.63), (5.01,0.535,5.23,0.755), (3.41,0.65,3.63,0.87), (0.21,0.9,0.43,1.12), (1.81,1.035,2.03,1.255), (4.21,1.05,4.43,1.27), (0.44,1.665,0.66,1.885), (4.785,1.665,5.005,1.885), (1.805,1.68,2.025,1.9), (2.835,1.68,3.055,1.9), (4.21,2.455,4.43,2.675), (5.01,2.595,5.23,2.815), (1.81,2.705,2.03,2.925), (4.21,2.925,4.43,3.145), (5.01,3.065,5.23,3.285), (1.01,3.165,1.23,3.385), (2.61,3.165,2.83,3.385), (0.21,3.29,0.43,3.51), (3.41,3.29,3.63,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,5.6,0.3), (1.005,0.3,1.235,0.69), (2.605,0.3,2.835,0.69), (3.405,0.53,5.29,0.76), (3.405,0.76,3.635,1.03), (0.205,0.84,0.435,1.03), (4.06,0.99,4.435,2.7), (0.205,1.03,3.635,1.26), (4.725,1.045,5.145,1.995), (0.34,1.57,0.665,2.025), (1.55,1.61,2.295,1.97), (2.83,1.61,3.065,2.2), (0.435,2.025,0.665,2.2), (0.435,2.2,3.065,2.43), (5.005,2.31,5.235,3.62), (1.75,2.7,4.435,2.93), (4.06,2.93,4.435,3.39), (0.95,3.16,2.89,3.39), (0.205,3.23,0.435,3.62), (3.405,3.23,3.635,3.62), (0,3.62,5.6,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,5.6,0.3), (4.06,0.99,4.435,3.39), (4.725,1.045,5.145,1.995), (0.34,1.57,0.665,2.025), (1.55,1.61,2.295,1.97), (0,3.62,5.6,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,6.03,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (2.8,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (2.8,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (0.502,1.797), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (1.922,1.79), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (4.935,1.52), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (4.247,2.19), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__oai21_2.gds')
