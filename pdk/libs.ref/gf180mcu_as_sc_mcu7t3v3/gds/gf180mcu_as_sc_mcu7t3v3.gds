* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__or4_4 A B C D VDD VNW VSS Y
XM1 n1 A VSS VSUBS nfet_03v3 w=1u l=0.28u
XM2 VSS B n1 VSUBS nfet_03v3 w=1u l=0.28u
XM3 n1 C VSS VSUBS nfet_03v3 w=1u l=0.28u
XM4 VSS D n1 VSUBS nfet_03v3 w=1u l=0.28u
XM5 Y n1 VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM6 n2 A n1 VNW pfet_03v3 w=1.38u l=0.28u
XM7 n3 B n2 VNW pfet_03v3 w=1.38u l=0.28u
XM8 n4 C n3 VNW pfet_03v3 w=1.38u l=0.28u
XM9 VDD D n4 VNW pfet_03v3 w=1.38u l=0.28u
XM10 Y n1 VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__or4_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,7.28,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,7.71,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,7.14,1.34), (0.14,2.2,7.14,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 4.58, 0.12, 0.28, 1.575, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 4.58, 1.93, 0.28, 1.87, 3, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.575), (1.38,0.12,1.66,1.6), (2.18,0.12,2.46,1.595), (2.98,0.12,3.26,1.59), (3.78,0.12,4.06,1.575), (0.275,1.575,0.86,1.95), (3.5,1.575,4.06,1.695), (2.74,1.59,3.26,1.96), (1.94,1.595,2.46,1.965), (1.34,1.6,1.7,1.97), (3.5,1.695,6.46,1.93), (3.5,1.93,4.06,1.995), (0.58,1.95,0.86,3.8), (2.98,1.96,3.26,3.8), (2.18,1.965,2.46,3.8), (1.38,1.97,1.66,3.8), (3.78,1.995,4.06,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,7.36,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,7.36,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 0.21, 0.41, 0.22, 0.22, 5, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 3.41, 3.29, 0.22, 0.22, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.01,0.805,1.23,1.025), (2.61,0.925,2.83,1.145), (4.21,1.05,4.43,1.27), (5.81,1.05,6.03,1.27), (0.37,1.65,0.59,1.87), (2.81,1.665,3.03,1.885), (2.01,1.675,2.23,1.895), (1.41,1.685,1.63,1.905), (3.57,1.7,3.79,1.92), (4.21,2.455,4.43,2.675), (5.81,2.455,6.03,2.675), (4.21,2.925,4.43,3.145), (5.81,2.925,6.03,3.145), (0.21,3.065,0.43,3.285)])
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 0.205, 0.3, 0.23, 0.39, 5, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 3.405, 3.23, 0.23, 0.39, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,7.28,0.3), (0.945,0.745,1.235,0.92), (0.945,0.92,3.795,1.15), (4.175,0.975,4.51,1.615), (5.775,0.975,6.11,1.615), (0.945,1.15,1.175,3.06), (3.52,1.15,3.795,2.015), (0.275,1.285,0.595,2.775), (1.405,1.58,1.735,3.25), (1.965,1.58,2.305,3.25), (2.715,1.58,3.125,3.24), (4.175,1.615,6.11,1.995), (4.175,1.995,4.51,3.39), (5.775,1.995,6.11,3.39), (0.205,3.005,0.435,3.06), (0.205,3.06,1.175,3.29), (0.205,3.29,0.435,3.345), (0,3.62,7.28,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,7.28,0.3), (4.175,0.975,4.51,3.39), (5.775,0.975,6.11,3.39), (0.275,1.285,0.595,2.775), (1.405,1.58,1.735,3.25), (1.965,1.58,2.305,3.25), (2.715,1.58,3.125,3.24), (0,3.62,7.28,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,7.71,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (3.64,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (3.64,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (0.435,2.03), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (1.57,2.415), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (2.135,2.415), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (2.92,2.41), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (5.942,2.182), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (4.342,2.182), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__or4_4.gds')
