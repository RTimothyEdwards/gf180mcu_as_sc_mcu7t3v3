* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__oa22_2 A B C D VDD VNW VSS Y
XM1 n1 C n2 VSUBS nfet_03v3 w=1u l=0.28u
XM2 n2 D n1 VSUBS nfet_03v3 w=1u l=0.28u
XM3 VSS B n2 VSUBS nfet_03v3 w=1u l=0.28u
XM4 n2 A VSS VSUBS nfet_03v3 w=1u l=0.28u
XM5 Y n1 VSS VSUBS nfet_03v3 w=1u l=0.28u m=2
XM6 n3 C VDD VNW pfet_03v3 w=1.38u l=0.28u
XM7 n1 D n3 VNW pfet_03v3 w=1.38u l=0.28u
XM8 n4 B n1 VNW pfet_03v3 w=1.38u l=0.28u
XM9 VDD A n4 VNW pfet_03v3 w=1.38u l=0.28u
XM10 Y n1 VDD VNW pfet_03v3 w=1.38u l=0.28u m=2
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__oa22_2')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,6.16,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,6.59,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,3.7,1.34), (3.98,0.34,6.02,1.34), (0.14,2.2,6.02,3.58)])
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.6), (1.38,0.12,1.66,1.565), (2.18,0.12,2.46,1.58), (2.98,0.12,3.26,1.58), (4.42,0.12,4.7,1.56), (5.22,0.12,5.5,1.685), (4.155,1.56,4.7,1.685), (1.38,1.565,1.76,2.015), (2.18,1.58,2.66,2.015), (2.98,1.58,3.385,2.025), (0.265,1.6,0.86,2.05), (4.155,1.685,5.5,1.915), (4.155,1.915,4.7,2.005), (5.22,1.915,5.5,3.8), (4.42,2.005,4.7,3.8), (1.38,2.015,1.66,3.8), (2.18,2.015,2.46,3.8), (2.98,2.025,3.26,3.8), (0.58,2.05,0.86,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,6.24,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,6.24,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 5.65, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(2.61,0.41,2.83,0.63), (4.05,0.41,4.27,0.63), (5.65,0.495,5.87,0.715), (1.81,0.68,2.03,0.9), (0.21,0.695,0.43,0.915), (3.41,0.925,3.63,1.145), (5.65,0.965,5.87,1.185), (1.01,1.05,1.23,1.27), (4.85,1.05,5.07,1.27), (1.47,1.665,1.69,1.885), (3.07,1.68,3.29,1.9), (4.245,1.69,4.465,1.91), (0.375,1.71,0.595,1.93), (2.325,1.715,2.545,1.935), (4.85,2.455,5.07,2.675), (4.85,2.925,5.07,3.145), (1.81,3.165,2.03,3.385), (0.21,3.29,0.43,3.51), (3.495,3.29,3.715,3.51), (3.965,3.29,4.185,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,6.16,0.3), (2.605,0.3,2.835,0.69), (4.045,0.3,4.275,0.69), (5.645,0.3,5.875,1.37), (0.205,0.53,2.035,0.76), (0.205,0.76,0.435,0.975), (1.805,0.76,2.035,0.92), (1.805,0.92,3.695,1.15), (1.005,0.99,1.235,3.16), (4.845,0.99,5.22,3.39), (0.265,1.435,0.735,2.355), (4.24,1.56,4.47,2.77), (1.465,1.565,1.81,2.87), (2.32,1.58,2.665,2.515), (2.98,1.58,3.385,2.025), (5.645,2.135,5.875,3.62), (2.945,2.77,4.47,3), (2.945,3,3.175,3.16), (1.005,3.16,3.175,3.39), (0.205,3.23,0.435,3.62), (3.405,3.23,4.275,3.62), (0,3.62,6.16,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,6.16,0.3), (4.845,0.99,5.22,3.39), (1.465,1.565,1.81,2.87), (2.32,1.58,2.665,2.515), (2.98,1.58,3.385,2.025), (0.265,1.6,0.735,2.05), (0,3.62,6.16,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,6.59,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (3.08,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (3.08,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (0.5,1.825), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (1.637,2.217), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (2.492,2.047), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (3.182,1.802), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (5.032,2.19), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__oa22_2.gds')
