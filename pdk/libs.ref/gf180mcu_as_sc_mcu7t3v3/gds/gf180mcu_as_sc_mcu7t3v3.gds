* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__oai211_4 A B C D VDD VNW VSS Y
XM1 VSS A n1 VSUBS nfet_03v3 w=1u l=0.28u m=4
XM2 n1 B VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM3 n2 C n1 VSUBS nfet_03v3 w=1u l=0.28u m=2
XM4 n3 C n1 VSUBS nfet_03v3 w=1u l=0.28u
XM5 Y D n3 VSUBS nfet_03v3 w=1u l=0.28u
XM6 n2 D Y VSUBS nfet_03v3 w=1u l=0.28u m=2
XM7 n4 D Y VSUBS nfet_03v3 w=1u l=0.28u
XM8 n1 C n4 VSUBS nfet_03v3 w=1u l=0.28u
XM9 n5 A VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
XM10 Y B n5 VNW pfet_03v3 w=1.38u l=0.28u m=4
XM11 Y C VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
XM12 VDD D Y VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
via1 = (35, 0)
metal2 = (36, 0)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__oai211_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,14,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,14.43,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,13.86,1.34), (0.14,2.2,13.86,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 0.58, 0.12, 0.28, 1.47, 8, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 6.98, 0.12, 0.28, 1.48, 7, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 0.58, 1.95, 0.28, 1.85, 8, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 6.98, 1.96, 0.28, 1.84, 7, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(12.58,0.12,12.86,1.585), (12.3,1.585,12.86,1.945), (0.58,1.59,2.46,1.95), (2.98,1.59,5.66,1.95), (5.9,1.59,6.46,1.95), (6.98,1.6,8.86,1.96), (9.38,1.6,12.06,1.96), (12.58,1.945,12.86,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,14.08,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,14.08,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 1.01, 0.41, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 8.21, 0.535, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 0.21, 0.925, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 0.815, 1.66, 0.22, 0.22, 3, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 3.16, 1.66, 0.22, 0.22, 5, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 7.08, 1.67, 0.22, 0.22, 4, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 9.585, 1.67, 0.22, 0.22, 5, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 7.41, 2.675, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 6.61, 3.29, 0.22, 0.22, 5, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(6.61,0.695,6.83,0.915), (7.41,0.995,7.63,1.215), (10.61,0.995,10.83,1.215), (12.37,1.655,12.59,1.875), (5.975,1.66,6.195,1.88), (3.41,2.675,3.63,2.895), (5.01,2.675,5.23,2.895), (1.01,2.775,1.23,2.995), (2.61,3.02,2.83,3.24), (4.21,3.165,4.43,3.385), (5.81,3.165,6.03,3.385), (0.21,3.29,0.43,3.51), (1.81,3.29,2.03,3.51)])
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 1.005, 0.3, 0.23, 0.39, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 6.605, 3.23, 0.23, 0.39, 5, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,14,0.3), (4.925,0.53,5.305,0.92), (6.605,0.53,8.715,0.76), (9.75,0.53,11.69,0.76), (12.6,0.53,13.31,0.76), (6.605,0.76,6.835,0.92), (11.39,0.76,11.69,1.02), (12.93,0.76,13.31,0.79), (0.205,0.865,0.435,0.92), (0.205,0.92,6.835,1.15), (7.35,0.99,10.89,1.22), (11.39,1.02,13.24,1.25), (0.205,1.15,0.435,1.205), (12.94,1.25,13.24,2.67), (12.365,1.585,12.595,2.19), (0.58,1.59,2.21,1.95), (2.98,1.59,5.38,1.95), (5.97,1.59,6.2,2.18), (6.98,1.6,8.75,1.96), (9.38,1.6,11.825,1.96), (1.98,1.95,2.21,2.18), (8.52,1.96,8.75,2.19), (1.98,2.18,6.2,2.41), (8.52,2.19,12.595,2.42), (3.35,2.67,13.24,2.9), (0.95,2.77,2.835,3), (2.605,3,2.835,3.16), (2.605,3.16,6.09,3.39), (0.205,3.23,0.435,3.62), (1.805,3.23,2.035,3.62), (0,3.62,14,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,14,0.3), (12.94,1.02,13.24,2.9), (0.58,1.59,2.21,1.95), (2.98,1.59,5.38,1.95), (6.98,1.6,8.75,1.96), (9.38,1.6,11.825,1.96), (0,3.62,14,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, via1, [(4.985,0.53,5.245,0.79), (12.99,0.53,13.25,0.79)])
R(gf180mcu_as_sc_mcu7t3v3_, metal2, [(4.925,0.52,5.28,0.53), (12.96,0.52,13.315,0.53), (4.925,0.53,13.315,0.81), (12.96,0.81,13.315,0.82)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,14.43,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (7,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (7,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (1.395,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (4.18,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (7.865,1.78), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (10.602,1.78), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (13.09,1.96), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__oai211_4.gds')
