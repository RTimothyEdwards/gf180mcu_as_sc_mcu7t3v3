* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__or3_4 A B C VDD VNW VSS Y
XM1 VSS A n1 VSUBS nfet_03v3 w=1u l=0.28u
XM2 n1 B VSS VSUBS nfet_03v3 w=1u l=0.28u
XM3 VSS C n1 VSUBS nfet_03v3 w=1u l=0.28u
XM4 Y n1 VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM5 n2 A n1 VNW pfet_03v3 w=1.38u l=0.28u
XM6 n3 B n2 VNW pfet_03v3 w=1.38u l=0.28u
XM7 VDD C n3 VNW pfet_03v3 w=1.38u l=0.28u
XM8 Y n1 VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__or3_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,6.72,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,7.15,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,6.1,1.34), (0.14,2.2,6.1,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 3.78, 0.12, 0.28, 1.48, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 3.78, 1.95, 0.28, 1.85, 3, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.555), (1.38,0.12,1.66,1.565), (2.18,0.12,2.46,1.565), (2.98,0.12,3.26,1.595), (0.265,1.555,0.86,1.98), (1.115,1.565,1.66,1.99), (2.18,1.565,2.64,1.99), (2.88,1.595,3.26,1.6), (2.88,1.6,5.66,1.95), (2.88,1.95,3.26,1.965), (2.98,1.965,3.26,3.8), (0.58,1.98,0.86,3.8), (1.38,1.99,1.66,3.8), (2.18,1.99,2.46,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,6.8,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,6.8,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 1.01, 0.41, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 2.61, 3.29, 0.22, 0.22, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(0.21,0.865,0.43,1.085), (1.81,0.925,2.03,1.145), (3.41,1.025,3.63,1.245), (5.01,1.025,5.23,1.245), (2.35,1.66,2.57,1.88), (0.335,1.67,0.555,1.89), (1.185,1.675,1.405,1.895), (2.95,1.675,3.17,1.895), (3.41,2.41,3.63,2.63), (5.01,2.41,5.23,2.63), (3.41,2.88,3.63,3.1), (5.01,2.88,5.23,3.1), (0.21,2.885,0.43,3.105)])
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 1.005, 0.3, 0.23, 0.39, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 2.605, 3.23, 0.23, 0.39, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,6.72,0.3), (0.205,0.76,0.435,0.92), (1.805,0.865,2.035,0.92), (0.205,0.92,2.035,1.15), (2.315,0.92,2.685,1.99), (3.405,0.95,3.78,1.6), (5.005,0.95,5.38,1.6), (0.205,1.15,0.435,1.155), (1.805,1.15,2.035,2.58), (0.265,1.42,0.62,2.475), (1.115,1.56,1.47,2.82), (2.945,1.595,3.175,2.58), (3.405,1.6,5.38,1.95), (3.405,1.95,3.78,3.28), (5.005,1.95,5.38,3.28), (1.805,2.58,3.175,2.81), (0.205,2.77,0.435,3.16), (1.805,2.81,2.035,3.16), (0.205,3.16,2.035,3.39), (0,3.62,6.72,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,6.72,0.3), (2.315,0.92,2.685,1.99), (3.405,0.95,3.78,3.28), (5.005,0.95,5.38,3.28), (0.265,1.42,0.62,2.475), (1.115,1.56,1.47,2.82), (0,3.62,6.72,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,7.15,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (3.36,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (3.36,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (5.192,2.115), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (3.592,2.115), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (1.292,2.19), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (0.442,1.947), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (2.5,1.455), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__or3_4.gds')
